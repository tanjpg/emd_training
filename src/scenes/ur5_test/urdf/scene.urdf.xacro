Commit message: EMD Training material

File: src/scenes/ur5_test/urdf/scene.urdf.xacro (robot description, xacro)
@@ -40,5 +40,5 @@
     <parent link="tool0"/>
     <child link="ee_palm"/>
-    <origin xyz="0 0 0.09" rpy="0 0 0"/>
+    <origin xyz="0 0 0.135" rpy="0 0 0"/>
  </joint>
 </robot>
